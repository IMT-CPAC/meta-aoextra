require labjack-lib.inc

SRC_URI[md5sum] = "3c27fb9746713e4cbb17878421fb4aa5"
SRC_URI[sha256sum] = "b47c4254087f9728fd3082595ad6448684d5df2a5577d6ddc519e654c0579bae"



