require python-labjack.inc

SRC_URI[md5sum] = "19a23af18424d2a506f34d65b8b9ce3d"
SRC_URI[sha256sum] = "0a309074aafac1ab43ba48baee385a7a82eec8285bdecedd0dec443b84fbf102"

inherit setuptools3
