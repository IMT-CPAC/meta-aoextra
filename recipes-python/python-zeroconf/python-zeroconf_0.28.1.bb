require python-zeroconf.inc

inherit setuptools
