require python-reloader.inc

inherit setuptools
