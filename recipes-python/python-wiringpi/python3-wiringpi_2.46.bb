inherit setuptools3

require python-wiringpi.inc

DEPENDS += "python-native python-setuptools-native"
